# Keil uVision project XO Game.uvproj, settings and files
target XO Game (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: XO Game
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;.\drivers\ADC;.\drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: XO Game.c main.c
    ./drivers/: TExaS.c startup.s
    ./drivers/GPIO/: GPIO_program.c
    ./drivers/NVIC/: NVIC_program.c
    ./drivers/TIMER/: Timer.c
    ./drivers/UART/: UART.c UART.h
    ./drivers/NOKIA5110/: Nokia5110.c
    ./drivers/LED/: LED.c
    ./drivers/ADC/: ADC.c ADC.h
